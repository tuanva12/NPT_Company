<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MH_DA_Form STM8S.ewp</path>
  </project>
  <batchBuild/>
</workspace>


